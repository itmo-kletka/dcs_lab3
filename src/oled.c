#include "oled.h"
#include "i2c_bus.h"
#include "stm32f4xx_hal.h"

#include <string.h>

#define OLED_I2C_ADDR 0x78u
#define OLED_BUF_SIZE (OLED_WIDTH * OLED_HEIGHT / 8)

static uint8_t vram[OLED_BUF_SIZE];
static uint8_t cur_x;
static uint8_t cur_y;

/* Компактный шрифт 5x7 для ASCII 0x20..0x7E (по 5 столбцов на символ, младший бит — верх) */
static const uint8_t font5x7[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, /* ' ' */
    {0x00, 0x00, 0x5F, 0x00, 0x00}, /* '!' */
    {0x00, 0x07, 0x00, 0x07, 0x00}, /* '"' */
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, /* '#' */
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, /* '$' */
    {0x23, 0x13, 0x08, 0x64, 0x62}, /* '%' */
    {0x36, 0x49, 0x55, 0x22, 0x50}, /* '&' */
    {0x00, 0x05, 0x03, 0x00, 0x00}, /* '\'' */
    {0x00, 0x1C, 0x22, 0x41, 0x00}, /* '(' */
    {0x00, 0x41, 0x22, 0x1C, 0x00}, /* ')' */
    {0x14, 0x08, 0x3E, 0x08, 0x14}, /* '*' */
    {0x08, 0x08, 0x3E, 0x08, 0x08}, /* '+' */
    {0x00, 0x50, 0x30, 0x00, 0x00}, /* ',' */
    {0x08, 0x08, 0x08, 0x08, 0x08}, /* '-' */
    {0x00, 0x60, 0x60, 0x00, 0x00}, /* '.' */
    {0x20, 0x10, 0x08, 0x04, 0x02}, /* '/' */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* '0' */
    {0x00, 0x42, 0x7F, 0x40, 0x00}, /* '1' */
    {0x42, 0x61, 0x51, 0x49, 0x46}, /* '2' */
    {0x21, 0x41, 0x45, 0x4B, 0x31}, /* '3' */
    {0x18, 0x14, 0x12, 0x7F, 0x10}, /* '4' */
    {0x27, 0x45, 0x45, 0x45, 0x39}, /* '5' */
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, /* '6' */
    {0x01, 0x71, 0x09, 0x05, 0x03}, /* '7' */
    {0x36, 0x49, 0x49, 0x49, 0x36}, /* '8' */
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* '9' */
    {0x00, 0x36, 0x36, 0x00, 0x00}, /* ':' */
    {0x00, 0x56, 0x36, 0x00, 0x00}, /* ';' */
    {0x08, 0x14, 0x22, 0x41, 0x00}, /* '<' */
    {0x14, 0x14, 0x14, 0x14, 0x14}, /* '=' */
    {0x00, 0x41, 0x22, 0x14, 0x08}, /* '>' */
    {0x02, 0x01, 0x51, 0x09, 0x06}, /* '?' */
    {0x32, 0x49, 0x79, 0x41, 0x3E}, /* '@' */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* 'A' */
    {0x7F, 0x49, 0x49, 0x49, 0x36}, /* 'B' */
    {0x3E, 0x41, 0x41, 0x41, 0x22}, /* 'C' */
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* 'D' */
    {0x7F, 0x49, 0x49, 0x49, 0x41}, /* 'E' */
    {0x7F, 0x09, 0x09, 0x09, 0x01}, /* 'F' */
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, /* 'G' */
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* 'H' */
    {0x00, 0x41, 0x7F, 0x41, 0x00}, /* 'I' */
    {0x20, 0x40, 0x41, 0x3F, 0x01}, /* 'J' */
    {0x7F, 0x08, 0x14, 0x22, 0x41}, /* 'K' */
    {0x7F, 0x40, 0x40, 0x40, 0x40}, /* 'L' */
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, /* 'M' */
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, /* 'N' */
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* 'O' */
    {0x7F, 0x09, 0x09, 0x09, 0x06}, /* 'P' */
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, /* 'Q' */
    {0x7F, 0x09, 0x19, 0x29, 0x46}, /* 'R' */
    {0x46, 0x49, 0x49, 0x49, 0x31}, /* 'S' */
    {0x01, 0x01, 0x7F, 0x01, 0x01}, /* 'T' */
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, /* 'U' */
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, /* 'V' */
    {0x3F, 0x40, 0x38, 0x40, 0x3F}, /* 'W' */
    {0x63, 0x14, 0x08, 0x14, 0x63}, /* 'X' */
    {0x07, 0x08, 0x70, 0x08, 0x07}, /* 'Y' */
    {0x61, 0x51, 0x49, 0x45, 0x43}, /* 'Z' */
    {0x00, 0x7F, 0x41, 0x41, 0x00}, /* '[' */
    {0x02, 0x04, 0x08, 0x10, 0x20}, /* '\\' */
    {0x00, 0x41, 0x41, 0x7F, 0x00}, /* ']' */
    {0x04, 0x02, 0x01, 0x02, 0x04}, /* '^' */
    {0x40, 0x40, 0x40, 0x40, 0x40}, /* '_' */
    {0x00, 0x01, 0x02, 0x04, 0x00}, /* '`' */
    {0x20, 0x54, 0x54, 0x54, 0x78}, /* 'a' */
    {0x7F, 0x48, 0x44, 0x44, 0x38}, /* 'b' */
    {0x38, 0x44, 0x44, 0x44, 0x20}, /* 'c' */
    {0x38, 0x44, 0x44, 0x48, 0x7F}, /* 'd' */
    {0x38, 0x54, 0x54, 0x54, 0x18}, /* 'e' */
    {0x08, 0x7E, 0x09, 0x01, 0x02}, /* 'f' */
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, /* 'g' */
    {0x7F, 0x08, 0x04, 0x04, 0x78}, /* 'h' */
    {0x00, 0x44, 0x7D, 0x40, 0x00}, /* 'i' */
    {0x20, 0x40, 0x44, 0x3D, 0x00}, /* 'j' */
    {0x7F, 0x10, 0x28, 0x44, 0x00}, /* 'k' */
    {0x00, 0x41, 0x7F, 0x40, 0x00}, /* 'l' */
    {0x7C, 0x04, 0x18, 0x04, 0x78}, /* 'm' */
    {0x7C, 0x08, 0x04, 0x04, 0x78}, /* 'n' */
    {0x38, 0x44, 0x44, 0x44, 0x38}, /* 'o' */
    {0x7C, 0x14, 0x14, 0x14, 0x08}, /* 'p' */
    {0x08, 0x14, 0x14, 0x18, 0x7C}, /* 'q' */
    {0x7C, 0x08, 0x04, 0x04, 0x08}, /* 'r' */
    {0x48, 0x54, 0x54, 0x54, 0x20}, /* 's' */
    {0x04, 0x3F, 0x44, 0x40, 0x20}, /* 't' */
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, /* 'u' */
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, /* 'v' */
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, /* 'w' */
    {0x44, 0x28, 0x10, 0x28, 0x44}, /* 'x' */
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, /* 'y' */
    {0x44, 0x64, 0x54, 0x4C, 0x44}, /* 'z' */
    {0x00, 0x08, 0x36, 0x41, 0x00}, /* '{' */
    {0x00, 0x00, 0x7F, 0x00, 0x00}, /* '|' */
    {0x00, 0x41, 0x36, 0x08, 0x00}, /* '}' */
    {0x08, 0x04, 0x08, 0x10, 0x08}, /* '~' */
};

static void oled_hw_reset(void)
{
    uint32_t t0;

    /* Сброс OLED через младший сигнал P0 расширителя PCA9538 с адресом 0xE0 (раздел 1.8 пособия) */
    (void)i2c_bus_write_reg(PCA9538_SYS_ADDR, PCA9538_REG_OUTPUT, 0xFFu);
    (void)i2c_bus_write_reg(PCA9538_SYS_ADDR, PCA9538_REG_CONFIG, 0xFEu);

    (void)i2c_bus_write_reg(PCA9538_SYS_ADDR, PCA9538_REG_OUTPUT, 0xFEu);
    t0 = HAL_GetTick();
    while ((HAL_GetTick() - t0) < 2u) {
    }

    (void)i2c_bus_write_reg(PCA9538_SYS_ADDR, PCA9538_REG_OUTPUT, 0xFFu);
    t0 = HAL_GetTick();
    while ((HAL_GetTick() - t0) < 2u) {
    }
}

void oled_init(void)
{
    /* Таблица 3 пособия — последовательность инициализации SSD1306BZ с управляющим байтом 0x00 */
    static const uint8_t init_seq[] = {
        0x00u,
        0xAEu,
        0x20u, 0x00u,
        0xC8u,
        0x40u,
        0x81u, 0xFFu,
        0xA1u,
        0xA6u,
        0xA8u, 0x3Fu,
        0xA4u,
        0xD3u, 0x00u,
        0xD5u, 0xF0u,
        0xD9u, 0x22u,
        0xDAu, 0x12u,
        0xDBu, 0x20u,
        0x8Du, 0x14u,
        0xAFu
    };

    oled_hw_reset();
    (void)i2c_bus_transmit(OLED_I2C_ADDR, init_seq, sizeof(init_seq));
    oled_fill(0);
    oled_update();
}

void oled_fill(uint8_t color)
{
    memset(vram, color ? 0xFF : 0x00, sizeof(vram));
}

void oled_update(void)
{
    /* Таблица 4 пособия — сброс указателей столбцов (0..127) и страниц (0..7) */
    static const uint8_t reset_ptr[] = {
        0x00u,
        0x21u, 0x00u, 0x7Fu,
        0x22u, 0x00u, 0x07u
    };

    (void)i2c_bus_transmit(OLED_I2C_ADDR, reset_ptr, sizeof(reset_ptr));
    /* Передача 1024 байт видеопамяти с управляющим байтом 0x40 (D/C# = 1) */
    (void)i2c_bus_mem_write(OLED_I2C_ADDR, 0x40u, vram, OLED_BUF_SIZE);
}

void oled_set_cursor(uint8_t x, uint8_t y)
{
    cur_x = x;
    cur_y = y;
}

void oled_draw_pixel(int x, int y, uint8_t color)
{
    uint16_t idx;
    uint8_t mask;

    if (x < 0 || x >= OLED_WIDTH || y < 0 || y >= OLED_HEIGHT) {
        return;
    }

    idx = (uint16_t)((y / 8) * OLED_WIDTH + x);
    mask = (uint8_t)(1u << (y & 7));
    if (color) {
        vram[idx] |= mask;
    } else {
        vram[idx] &= (uint8_t)~mask;
    }
}

void oled_draw_line(int x0, int y0, int x1, int y1, uint8_t color)
{
    int dx = (x1 > x0) ? (x1 - x0) : (x0 - x1);
    int sx = (x0 < x1) ? 1 : -1;
    int dy = (y1 > y0) ? -(y1 - y0) : -(y0 - y1);
    int sy = (y0 < y1) ? 1 : -1;
    int err = dx + dy;

    while (1) {
        oled_draw_pixel(x0, y0, color);
        if (x0 == x1 && y0 == y1) {
            break;
        }
        int e2 = 2 * err;
        if (e2 >= dy) {
            err += dy;
            x0 += sx;
        }
        if (e2 <= dx) {
            err += dx;
            y0 += sy;
        }
    }
}

void oled_draw_circle(int cx, int cy, int r, uint8_t color)
{
    int x = r;
    int y = 0;
    int err = 1 - x;

    while (x >= y) {
        oled_draw_pixel(cx + x, cy + y, color);
        oled_draw_pixel(cx + y, cy + x, color);
        oled_draw_pixel(cx - y, cy + x, color);
        oled_draw_pixel(cx - x, cy + y, color);
        oled_draw_pixel(cx - x, cy - y, color);
        oled_draw_pixel(cx - y, cy - x, color);
        oled_draw_pixel(cx + y, cy - x, color);
        oled_draw_pixel(cx + x, cy - y, color);
        y++;
        if (err < 0) {
            err += 2 * y + 1;
        } else {
            x--;
            err += 2 * (y - x) + 1;
        }
    }
}

void oled_draw_arrow(int cx, int cy, int tip_x, int tip_y, uint8_t color)
{
    int dx = tip_x - cx;
    int dy = tip_y - cy;
    int px = -dy;
    int py = dx;

    oled_draw_line(cx, cy, tip_x, tip_y, color);

    /* Крылья стрелки у острия */
    int wing1_x = tip_x - (dx / 3) + (px / 5);
    int wing1_y = tip_y - (dy / 3) + (py / 5);
    int wing2_x = tip_x - (dx / 3) - (px / 5);
    int wing2_y = tip_y - (dy / 3) - (py / 5);

    oled_draw_line(tip_x, tip_y, wing1_x, wing1_y, color);
    oled_draw_line(tip_x, tip_y, wing2_x, wing2_y, color);
}

void oled_write_char(char ch, uint8_t color)
{
    uint8_t col;
    uint8_t row;

    if (ch < 0x20 || ch > 0x7E) {
        ch = '?';
    }
    if (cur_x + 6u > OLED_WIDTH) {
        return;
    }

    const uint8_t *glyph = font5x7[(uint8_t)(ch - 0x20)];
    for (col = 0; col < 5u; col++) {
        uint8_t bits = glyph[col];
        for (row = 0; row < 7u; row++) {
            uint8_t on = (bits >> row) & 1u;
            oled_draw_pixel(cur_x + col, cur_y + row, color ? on : (uint8_t)!on);
        }
    }
    for (row = 0; row < 7u; row++) {
        oled_draw_pixel(cur_x + 5u, cur_y + row, color ? 0u : 1u);
    }
    cur_x = (uint8_t)(cur_x + 6u);
}

void oled_write_str(const char *s, uint8_t color)
{
    if (s == 0) {
        return;
    }
    while (*s) {
        oled_write_char(*s, color);
        s++;
    }
}

void oled_write_str_at(uint8_t x, uint8_t y, const char *s, uint8_t color)
{
    oled_set_cursor(x, y);
    oled_write_str(s, color);
}
